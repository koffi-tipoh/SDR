options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: chan_width
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 60e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: tuner_freq
  id: variable_qtgui_entry
  parameters:
    comment: |-
      230k - triangle wave
      350k - sawtooth wave
      435k - square wave
    type: real
    value: 435e3
  states: {}
- name: analog_sig_source_x_1_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-1*tuner_freq'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../tuner_test_c0_s1M.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_xx_0_3
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: chan_width/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: chan_width/20
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Input"'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Tuned"'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    size: 1024*4
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_1_0_1, '0', blocks_multiply_xx_0_3, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0_3, '0', low_pass_filter_2, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0_3, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_2, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_2, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
