options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '100'
    stop: 2e3
    value: '200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '32'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/32
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_throttle2_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
